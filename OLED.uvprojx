# Keil uVision project OLED.uvprojx, settings and files
target OLED (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;                                                             ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                             ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                             ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                                             ../Drivers/CMSIS/Include;                                    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                                    ../Middlewares/Third_Party/FreeRTOS/Source/include;                                    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: spi.c usart.c gpio.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c dma.c main.c i2c.c hex_gen.c rtc.c data_acquisition.c MPVV436744-013.c adc.c Ana_board.c my_comm.c xprintf.c ftoa.c freertos.c stm32f1xx_hal_timebase_TIM.c enc28j60.c lan.c MQTT_SN_task.c json.c watchdog.c iwdg.c ntp.c nvmem.c conf_fn.c crc.c tftp_server.c mystrcpy.c TFTP_ser_desesr.c
    ../Inc/: nctrl.h globaldef.h TFTP_data.h debug_settings.h
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c queue.c croutine.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group MQTTSNPacket
    ../Src/MQTTSNPacket/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c
    ../Inc/MQTTSNPacket/: StackTrace.h
target QUQU (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: OLED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: as above
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
